MIRRORS_append () {
ftp://.*/.*    https://github.com/ralph-irving/squeezeos-pokycache/raw/refs/heads/public/${SQUEEZEOS_DISTRO_VERSION}/distfiles/
http://.*/.*   https://github.com/ralph-irving/squeezeos-pokycache/raw/refs/heads/public/${SQUEEZEOS_DISTRO_VERSION}/distfiles/
https://.*/.*  https://github.com/ralph-irving/squeezeos-pokycache/raw/refs/heads/public/${SQUEEZEOS_DISTRO_VERSION}/distfiles/
}
